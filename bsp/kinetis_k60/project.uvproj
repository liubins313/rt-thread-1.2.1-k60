# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: template +hex
  c flags: Optim=1
  c define: MK60D10 CHK60EVB2 DEBUG
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\CM4\DeviceSupport;Libraries\Kinetis_StdPeriph\inc;applications;drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c thread_sleep.c
  group Drivers
    drivers/: board.c rtt_serial.c
  group K60_StdPeriph
    Libraries/CMSIS/CM4/DeviceSupport/: system_MK60D10.c
    Libraries/CMSIS/CM4/DeviceSupport/MDK-ARM/: startup_MK60D10.s
    Libraries/kinetis_StdPeriph/src/: adc.c can.c common.c cpuidy.c dac.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh_cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
